# IAR project 53L1A2_MultiSensorRanging.ewp, settings and files
configuration 53L1A2_MultiSensorRanging (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/vl53l1cb/modules; ../../../../../../Drivers/BSP/Components/vl53l1cb/porting; ../../../../../../Drivers/BSP/Components/vl53l1cb; ../../../../../../Drivers/BSP/53L1A2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 53L1A2_MultiSensorRanging.hex
  ILINK.IlinkOutputFile: 53L1A2_MultiSensorRanging.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_tof.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l1cb/modules/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_dmax.c vl53l1_error_strings.c vl53l1_hist_algos_gen3.c vl53l1_hist_algos_gen4.c vl53l1_hist_char.c vl53l1_hist_core.c vl53l1_hist_funcs.c vl53l1_nvm.c vl53l1_nvm_debug.c vl53l1_register_funcs.c vl53l1_sigma_estimate.c vl53l1_silicon_core.c vl53l1_wait.c vl53l1_xtalk.c vl53l1_zone_presets.c
    ../../../../../../Drivers/BSP/Components/vl53l1cb/porting/: vl53l1_platform.c vl53l1_platform_ipp.c vl53l1_platform_log.c
    ../../../../../../Drivers/BSP/Components/vl53l1cb/: vl53l1cb.c
  group Drivers/BSP/53L1A2
    ../../../../../../Drivers/BSP/53L1A2/: 53l1a2.c 53l1a2_ranging_sensor.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../../Drivers/BSP/Components/vl53l1cb/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l1cb/modules/: ReleaseNotes.txt
    ../../../../../../Drivers/BSP/53L1A2/: LICENSE.txt
