# Keil uVision project 53L4A1_ThresholdDetection.uvprojx, settings and files
target 53L4A1_ThresholdDetection (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 53L4A1_ThresholdDetection +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/vl53l4cd/modules;../../../../../../Drivers/BSP/Components/vl53l4cd/porting;../../../../../../Drivers/BSP/Components/vl53l4cd;../../../../../../Drivers/BSP/53L4A1
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_tof_pin_conf.c app_tof.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l4cd/modules/: vl53l4cd_api.c vl53l4cd_calibration.c
    ../../../../../../Drivers/BSP/Components/vl53l4cd/porting/: platform.c
    ../../../../../../Drivers/BSP/Components/vl53l4cd/: vl53l4cd.c
  group Drivers/BSP/53L4A1
    ../../../../../../Drivers/BSP/53L4A1/: 53l4a1_ranging_sensor.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../../Drivers/BSP/Components/vl53l4cd/: LICENSE.txt
    ../../../../../../Drivers/BSP/53L4A1/: LICENSE.txt
software components: CMSIS:CORE 5.6.0
