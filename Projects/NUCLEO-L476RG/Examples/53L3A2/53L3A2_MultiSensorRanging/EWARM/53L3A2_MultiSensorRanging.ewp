# IAR project 53L3A2_MultiSensorRanging.ewp, settings and files
configuration 53L3A2_MultiSensorRanging (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/53L3A2; ../../../../../../Drivers/BSP/Components/vl53l3cx/modules; ../../../../../../Drivers/BSP/Components/vl53l3cx/porting; ../../../../../../Drivers/BSP/Components/vl53l3cx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 53L3A2_MultiSensorRanging.hex
  ILINK.IlinkOutputFile: 53L3A2_MultiSensorRanging.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c app_tof.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l3cx/modules/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_register_funcs.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c
    ../../../../../../Drivers/BSP/Components/vl53l3cx/porting/: vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c
    ../../../../../../Drivers/BSP/Components/vl53l3cx/: vl53l3cx.c
  group Drivers/BSP/53L3A2
    ../../../../../../Drivers/BSP/53L3A2/: 53l3a2.c 53l3a2_ranging_sensor.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../../Drivers/BSP/53L3A2/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l3cx/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l3cx/modules/: LXReleaseNotes.txt
