<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\VL53L4ED_SimpleRanging.ewp</path>
  </project>
  <batchBuild />
</workspace>
