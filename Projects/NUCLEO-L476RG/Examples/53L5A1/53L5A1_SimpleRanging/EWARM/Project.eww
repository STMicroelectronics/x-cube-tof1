<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\53L5A1_SimpleRanging.ewp</path>
  </project>
  <batchBuild />
</workspace>
