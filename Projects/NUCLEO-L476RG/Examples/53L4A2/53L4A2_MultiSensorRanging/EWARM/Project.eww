<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\53L4A2_MultiSensorRanging.ewp</path>
  </project>
  <batchBuild />
</workspace>
